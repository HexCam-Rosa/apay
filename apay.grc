options:
  parameters:
    author: Rosa
    copyright: Apache 2
    generate_options: no_gui
    id: apay
    output_language: cpp
    title: apay
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}

connections:
- [audio_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
