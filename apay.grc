options:
  parameters:
    author: Rosa
    copyright: Apache 2
    generate_options: qt_gui
    id: apay
    output_language: python
    title: apay
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: mod_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: rrc_taps_0
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[(-3-3j), (-1-3j), (1-3j), (3-3j), (-3-1j), (-1-1j), (1-1j), (3-1j), (-3+1j), (-1+1j), (1+1j), (3+1j), (-3+3j), (-1+3j), (1+3j), (3+3j)]'
    dims: '4'
    precision: '8'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]'
    type: qpsk
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.44'
    freq: mod_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-1.44'
    freq: mod_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_2_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (5, 1, 5,1)
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /home/david/apay/test-3.wav
    samp_rate: samp_rate
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: '0'
    noise_voltage: '0'
    seed: '0'
    taps: taps
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.628'
    max_dev: '1.5'
    osps: '1'
    sps: sps*1.000
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      import pmt
      import base64

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.byte]
              )
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.toSend = np.array([], dtype=np.uint8)
              
          def handle_msg(self, msg):
              temp = pmt.symbol_to_string(msg)
              out = np.frombuffer(base64.binascii.a2b_base64(temp.encode("ascii")), dtype=np.int8)
              self.toSend = np.append(self.toSend, out)

          def work(self, input_items, output_items):
              toSendSize = self.toSend.size
              if toSendSize == 0:
                  return 0
              
              for i, byteToSend in enumerate(self.toSend):
                  output_items[0][i] = byteToSend
              
              self.toSend = np.array([], dtype=np.int8)
              return toSendSize
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (samp_rate//sps)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: (samp_rate//(2*sps))
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    size: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: wav_source
  id: blocks_wavfile_source
  parameters:
    file: /home/david/apay/test-3.wav
    repeat: 'True'
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:4030
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:4020
    timeout: '100'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_sig_source_x_0, '0', blocks_float_to_complex_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_1, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_1, '1']
- [audio_source_0, '0', blocks_float_to_complex_2_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_complex_2, '0']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_1, '0', blocks_multiply_xx_2, '1']
- [blocks_float_to_complex_2, '0', blocks_multiply_xx_2, '0']
- [blocks_float_to_complex_2, '0', channels_channel_model_0, '0']
- [blocks_float_to_complex_2_0, '0', blocks_multiply_xx_2, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_2, '0', low_pass_filter_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_source_x_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_vector_source_x_1, '0', digital_constellation_modulator_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_xx_2, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', zeromq_pub_sink_0, '0']
- [digital_constellation_modulator_0, '0', blocks_complex_to_imag_0, '0']
- [digital_constellation_modulator_0, '0', blocks_complex_to_real_0, '0']
- [digital_constellation_modulator_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_diff_decoder_bb_0, '0', zeromq_pub_sink_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_1, '1']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_time_sink_x_0, '1']
- [epy_block_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [epy_block_0, '0', digital_constellation_modulator_0, '0']
- [low_pass_filter_0, '0', digital_constellation_decoder_cb_0, '0']
- [low_pass_filter_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [low_pass_filter_0, '0', qtgui_const_sink_x_1_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [wav_source, '0', blocks_float_to_complex_2_0, '0']
- [zeromq_sub_msg_source_0, out, epy_block_0, msg_in]

metadata:
  file_format: 1
